## package/mymodule/Config.in
```kconfig
config BR2_PACKAGE_MYMODULE
	bool "mymodule"
	depends on BR2_LINUX_KERNEL
	help
	  Build the hello world kernel module.
```
